# Keil uVision project 电子肺活量检测仪.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 电子肺活量检测仪 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 电子肺活量检测仪.c
