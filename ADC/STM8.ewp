# IAR project STM8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: USER; STM8S_StdPerph_Driver\inc; STM8S_StdPerph_Driver\src; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8.hex
  ILINK.IlinkOutputFile: STM8.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Readme
    Readme/: readme.txt
  group STM8S_StdPerph_Driver
    STM8S_StdPerph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_usart.c
  group USER
    USER/: adc.c com.c IIC.c main.c stm8l15x_it.c tim2.c Uart.c
